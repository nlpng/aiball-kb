# Repository nlpng/aiball-kb

File README.md:

# aiball keyboard
A 42-key splited keyboard inspired by [keyball](https://github.com/Yowkees/keyball) and [roBa](https://github.com/kumamuk-git/roBa), which has feature of trackball and wireless.

# Changes
The keyboard is based on roBa keyboard, and rework to fit my personal needs, since Corne keyboard layout is preferred, the key access feels better and more compact to me.

## KiCad design pcbs/aiball_right/aiball_right.kicad_pcb

Board: 2 copper layers, 142.8 x 94.4 mm, 50 parts (1 on the bottom side), 37 nets.

Parts:
BT1: BATT; JST_S2B-PH-SM4-TB
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20: D; Diode_SMD
J1: pmw3610_connector
J2, J3, J4, J5, J6, J7: Conn_01x01-Connector_Generic; MountingHole_4.3mm_M4
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW13, SW14, SW15, SW17, SW18, SW19, SW20: SW_PUSH; SW_MX
SW12, SW16: SW_PUSH; SW_MX_Choc
SW21: SW_SPDT; TGSW_MSK-12D19
U1: XIAO_nRF52840_wBAT_wNFC_1

Connections:
3.3V: J1.4 (Vin), U1.12 (3V3)
Bat: BT1.1 (+), U1.20 (BATT+)
CS: J1.2 (nCS), U1.15 (NFC1_0.09)
Col0: SW1.1, SW2.1, SW3.1, SW4.1, U1.11 (P1.15_D10_MOSI)
Col1: SW5.1, SW6.1, SW7.1, SW8.1, U1.10 (P1.14_D9_MISO)
Col2: SW9.1, SW10.1, SW11.1, SW12.1, U1.9 (P1.13_D8_SCK)
Col3: SW13.1, SW14.1, SW15.1, SW16.1, U1.8 (P1.12_D7_RX)
Col4: SW17.1, SW18.1, SW19.1, SW20.1, U1.16 (NFC2_0.10)
GND: J1.3 (GND), SW21.3 (C), U1.13 (GND), U1.21 (BATT-)
MOTION: J1.7 (MOTION), U1.1 (P0.02_A0_D0)
unnamed: BT1.2 (-), SW21.2 (B)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
Row0: D1.1 (K), D5.1 (K), D9.1 (K), D13.1 (K), D17.1 (K), U1.2 (P0.03_A1_D1)
Row1: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), D18.1 (K), U1.3 (P0.28_A2_D2)
Row2: D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), D19.1 (K), U1.4 (P0.29_A3_D3)
Row3: D4.1 (K), D8.1 (K), D12.1 (K), D16.1 (K), D20.1 (K), U1.7 (P1.11_D6_TX)
SCLK: J1.1 (SCLK), U1.6 (P0.05_A5_D5_SCL)
SDIO: J1.6 (SDIO), U1.5 (P0.04_A4_D4_SDA)

File pcbs/aiball_right/jlcpcb/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,JST_S2B-PH-SM4-TB,1,BATT,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D3, D4, D5, D6, D7, D8, D9",Diode_SMD,20,D,
J1,pmw3610_connector,1,~,
"J2, J3, J4, J5, J6, J7",MountingHole_4.3mm_M4,6,Conn_01x01-Connector_Generic,
"SW1, SW10, SW11, SW13, SW14, SW15, SW17, SW18, SW19, SW2, SW20, SW3, SW4, SW5, SW6, SW7, SW8, SW9",SW_MX,18,SW_PUSH,
"SW12, SW16",SW_MX_Choc,2,SW_PUSH,
SW21,TGSW_MSK-12D19,1,SW_SPDT,
U1,XIAO_nRF52840_wBAT_wNFC_1,1,~,

## Commit log

2024-11-26 add cases
2024-11-27 add partial pcb files
